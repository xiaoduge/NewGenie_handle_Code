# Keil uVision project baseos.uvprojx, settings and files
target uCOSDemo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOSDemo +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL,USE_STM3210C_EVAL,
  c include: .\Source\CMSIS\CM3\CoreSupport;.\Source\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Source\FWLib\inc;.\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./Source/APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c stm32f10x_conf.h config.c Relay.c DICA.c Beep.c serial.c UartCmd.c AT.C display.c Printf.c LCD.c CanCmd.c touch.c cytma.c zb.c
  group FWLib
    ./Source/FWLib/src/: stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_cec.c
  group cmsis
    ./Source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ./Source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib
    ./lib/: 0862100000STM32F103.lib
  group font
    ./Source/font/: font.c
target SRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 0860210008PWHA_Main_V_1_0 +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM3210C_EVAL,xIAP,USE_USART1_STDIO,CAN_ADR_FILTER,SERIAL_DEBUG,CODEGB_48
  c include: .\Source\CMSIS\CM3\CoreSupport;.\Source\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Source\FWLib\inc;.\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\util;.\Source\BSP\Common;.\Source\FATFS;.\Source\STM32_USB-FS-Device_Driver\inc;.\Source\HAL\USBCDC;.\Source\font;.\Source\SD_Card;.\Source\SD_Card\SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.1.1
